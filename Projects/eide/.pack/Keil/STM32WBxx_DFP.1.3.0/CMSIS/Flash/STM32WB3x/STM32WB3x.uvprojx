# Keil uVision project STM32WB3x.uvprojx, settings and files
target STM32WB3x_M4_512 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: STM32WB3x_512_M4
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1
  c define: FLASH_MEM, STM32WB3x_M4_512
  c misc: --C99
  c include: ..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include;..\..\..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32WB3x_M4_256 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: STM32WB3x_256_M4
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: FLASH_MEM, STM32WB3x_M4_256
  c misc: --C99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.4.0
